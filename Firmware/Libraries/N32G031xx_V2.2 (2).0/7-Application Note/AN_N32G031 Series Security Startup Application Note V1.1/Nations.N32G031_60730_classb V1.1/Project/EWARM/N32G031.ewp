# IAR project N32G031.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G031C8 Nations N32G031C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: N32G031; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..; ..\..\Drivers\CMSIS\Include; ..\..\Drivers\n32g031_std_periph_driver\Inc; ..\..\Drivers\CMSIS\Device\Nations\N32G0xx\Include; ..\..\Middlewares\N32_SelfTest_Library\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: N32G031.hex
  ILINK.IlinkOutputFile: N32G031.out
  ILINK.IlinkIcfFile: N32G031x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../Drivers/CMSIS/Device/Nations/N32G0xx/Source/Templates/iar/: startup_n32g031_EWARM.S
  group Application/User
    ../: main.c n32g0xx_it.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/Nations/N32G0xx/Source/Templates/: system_n32g031.c
  group Drivers/N32_SelfTest_Code
    ./: n32g0xx_STLcpurunIAR.s n32g0xx_STLcpustartIAR.s n32g0xx_STLRamMcMxIAR.s
  group Drivers/N32_SelfTest_Library
    ../../Middlewares/N32_SelfTest_Library/src/: n32g0xx_STLclockrun.c n32g0xx_STLclockstart.c n32g0xx_STLcrc32Run.c n32g0xx_STLmain.c n32g0xx_STLstartup.c n32g0xx_STLtranspRam.c
  group Drivers/N32G031_Periph
    ../../Drivers/n32g031_std_periph_driver/Src/: misc.c n32g031_crc.c n32g031_dbg.c n32g031_flash.c n32g031_gpio.c n32g031_iwdg.c n32g031_pwr.c n32g031_rcc.c n32g031_rtc.c n32g031_tim.c n32g031_usart.c n32g031_wwdg.c
