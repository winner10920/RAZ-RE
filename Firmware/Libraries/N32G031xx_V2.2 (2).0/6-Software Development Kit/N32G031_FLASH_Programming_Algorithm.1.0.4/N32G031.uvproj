# Keil uVision project N32G031.uvproj, settings and files
target N32G031x_64 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: N32G031x_64
  AfterMake: cmd.exe /C copy N32G031x_64.axf ..\N32G031x_64.FLM
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM, N32G031x_64
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target N32G031x_32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: N32G031x_32
  AfterMake: cmd.exe /C copy N32G031x_32.axf ..\N32G031x_32.FLM
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM, N32G031x_32
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target N32G031x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: N32G031x
  AfterMake: cmd.exe /C copy N32G031x.axf ..\N32G031x.FLM
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: FLASH_MEM, N32G031x_64
  c include: .\..
  asm include: .\..
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
